SYSTEMD_AUTO_ENABLE:${PN}-examples = "disable"
